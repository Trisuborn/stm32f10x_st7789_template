# Keil uVision project f103_template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: f103_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\core;.\inc;.\lib\inc;.\main;.\driver\iic;.\driver\usart;.\driver\lcd_st7789;.\driver\touch\CTP;.\third_party\rt-thread-sorted;.\third_party\rt-thread-sorted\src;.\third_party\rt-thread-sorted\include;.\third_party\rt-thread-sorted\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group lib
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group main
    ./main/: main.c
  group inc
    ./inc/: core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
  group driver
    ./driver/usart/: usart.c
    ./driver/touch/CTP/: ft6236.c
    ./driver/iic/: iic_conf.c
    ./driver/lcd_st7789/: lcd_st7789.c
  group rtt_nano/kernal
    ./third_party/rt-thread-sorted/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ./third_party/rt-thread-sorted/: board.c context_rvds.S cpuport.c
  group rtt_nano/finsh
    ./third_party/rt-thread-sorted/finsh/: cmd.c msh.c shell.c
  group rtt_nano/user
    ./third_party/rt-thread-sorted/: rtconfig.h user_cmd.c
